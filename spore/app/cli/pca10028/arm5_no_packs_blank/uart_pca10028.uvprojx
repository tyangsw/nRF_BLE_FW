# Keil uVision project uart_pca10028.uvprojx, settings and files
target nrf51422_xxac (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51 SERIAL_DEBUG
  c misc: --c99
  c include: ..\..\config\spore_pca10028;..\..\config;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\components\libraries\uart;..\..\..\..\..\components\libraries\util;..\..\..\..\bsp;..\..;..\..\..\..\common
  asm define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../components/libraries/uart/: retarget.c
  group Spore_common
    ../../../../common/: uart.c menu.c i2c.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0
